<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk31</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_taps</value></param>
<param><key>value</key><value>[1.0/samp_per_sym] * samp_per_sym</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>12</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>doppler</value></param>
<param><key>value</key><value>-2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>55</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>int(samp_rate/31.25)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>float(samp_rate)/samp_per_sym</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>test_string</value></param>
<param><key>value</key><value>map(ord, 'The quick brown fox jumps over the lazy dog.\n')</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/dev/stdout</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>samples_per_second</key><value>sym_rate*10</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>test_string</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.001</value></param>
<param><key>freq_offset</key><value>2*pi*freq_offset/samp_rate</value></param>
<param><key>noise_voltage</key><value>1.0e-3 * 10**(noise/20.0)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>channels_selective_fading_model</key>
<param><key>id</key><value>channels_selective_fading_model_0</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>2*pi*10**doppler/samp_rate</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>8</value></param>
<param><key>delays</key><value>0.0,0.1,1.3</value></param>
<param><key>mags</key><value>1,0.99,0.97</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>psk31_coherent_demodulator</key>
<param><key>id</key><value>psk31_coherent_demodulator_0</value></param>
<param><key>agc_time_const</key><value>8.0</value></param>
<param><key>sync_bandwidth</key><value>0.6</value></param>
<param><key>sync_phases</key><value>32</value></param>
<param><key>costas_bandwidth</key><value>0.15</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
</block>
<block>
<key>psk31_constellation_decoder</key>
<param><key>id</key><value>psk31_constellation_decoder_0</value></param>
<param><key>differential_decode</key><value>True</value></param>
<param><key>varicode_decode</key><value>True</value></param>
</block>
<block>
<key>psk31_modulator_bc</key>
<param><key>id</key><value>psk31_modulator_bc_0</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*8</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>radioteletype_varicode_encode_bb</key>
<param><key>id</key><value>radioteletype_varicode_encode_bb_0</value></param>
</block>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>psk31_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>radioteletype_varicode_encode_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>psk31_coherent_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_selective_fading_model_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk31_coherent_demodulator_0</source_block_id><sink_block_id>psk31_constellation_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk31_coherent_demodulator_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk31_constellation_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk31_modulator_bc_0</source_block_id><sink_block_id>channels_selective_fading_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radioteletype_varicode_encode_bb_0</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
