options:
  parameters:
    generate_options: qt_gui
    id: viterbi_vs_pskcore
    output_language: python
  states: {}

blocks:
- name: ber_window
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: block
  id: variable
  parameters:
    value: bpsym*1000
  states: {}
- name: bpsym
  id: variable
  parameters:
    value: int(round(math.log(fsm.I())/math.log(2)))
  states: {}
- name: channel
  id: variable
  parameters:
    comment: |-
      This is the net impulse response of the receive
      and transmit filters, at 1 bit per symbol.
    value: '[1.0/6, 1.0, 1.0/6]'
  states: {}
- name: fsm
  id: variable
  parameters:
    value: trellis.fsm(len(modulation[1]),len(channel))
  states: {}
- name: modulation
  id: variable
  parameters:
    value: (1, [-1, 1])
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.535'
  states: {}
- name: pskcore_energy
  id: variable
  parameters:
    value: sum(i*i for i in pskcore_taps)
  states: {}
- name: pskcore_taps
  id: variable
  parameters:
    value: (4.3453566e-005, -0.00049122414, -0.00078771292, -0.0013507826, -0.0021287814, -0.003133466, -0.004366817, -0.0058112187, -0.0074249976, -0.0091398882, -0.010860157, -0.012464086, -0.013807772, -0.014731191, -0.015067057, -0.014650894, -0.013333425, -0.01099166, -0.0075431246, -0.0029527849, 0.0027546292, 0.0094932775, 0.017113308, 0.025403511, 0.034099681, 0.042895839, 0.051458575, 0.059444853, 0.066521003, 0.072381617, 0.076767694, 0.079481619, 0.080420311, 0.079481619, 0.076767694, 0.072381617, 0.066521003, 0.059444853, 0.051458575, 0.042895839, 0.034099681, 0.025403511, 0.017113308, 0.0094932775, 0.0027546292, -0.0029527849, -0.0075431246, -0.01099166, -0.013333425, -0.014650894, -0.015067057, -0.014731191, -0.013807772, -0.012464086, -0.010860157, -0.0091398882, -0.0074249976, -0.0058112187, -0.004366817, -0.003133466, -0.0021287814, -0.0013507826, -0.00078771292, -0.00049122414, 4.3453566e-005)
  states: {}
- name: raised_cos
  id: variable
  parameters:
    value: filters.raised_cos_impulse(samp_per_sym*2)
  states: {}
- name: raised_cos_energy
  id: variable
  parameters:
    value: sum(i*i for i in raised_cos)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    comment: |-
      PSKCore taps require 16
      samples per symbol
    value: int(samp_rate/31.25)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: float(samp_rate)/samp_per_sym
  states: {}
- name: tot_mod
  id: variable
  parameters:
    value: fu.make_isi_lookup(modulation,channel,False)
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '2731'
    repeat: 'True'
    type: byte
  states: {}
- name: blks2_error_rate_0
  id: blks2_error_rate
  parameters:
    bits_per_symbol: '1'
    type: '''BER'''
    win_size: ber_window
  states: {}
- name: blks2_error_rate_0_0
  id: blks2_error_rate
  parameters:
    bits_per_symbol: '1'
    type: '''BER'''
    win_size: ber_window
  states: {}
- name: blks2_error_rate_0_0_0
  id: blks2_error_rate
  parameters:
    bits_per_symbol: '1'
    type: '''BER'''
    win_size: ber_window
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {state: disabled}
- name: blocks_delay_1_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: byte
  states: {}
- name: blocks_delay_1_0_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_1_1
  id: blocks_delay
  parameters:
    delay: '3'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: modulation[1]
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '16'
    taps: '[i // raised_cos_energy**0.5 for i in raised_cos]'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_1_0
  id: fir_filter_xxx
  parameters:
    decim: '16'
    taps: '[i / pskcore_energy**0.5 for i in pskcore_taps]'
    type: ccf
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: channel
    type: fff
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import gnuradio.trellis.fsm_utils as fu
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.radioteletype import filters
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: samp_per_sym
    taps: '[i // raised_cos_energy**0.5 for i in raised_cos]'
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: modulator
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: receive filtering
  states: {}
- name: note_1
  id: note
  parameters:
    note: decoding
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: instrumentation
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: matched
    label2: pskcore
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Viterbi
    label2: PSKCore
    label3: No EQ
    min: '0'
    name: '"BER %"'
    nconnections: '3'
    type: float
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: tot_mod[0]
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: tot_mod[1]
    type: f
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: block//bpsym
    final_state: '-1'
    fsm_args: fsm
    init_state: '-1'
    type: b
  states: {}
- name: virtual_sink
  id: virtual_sink
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decimated
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: pskcore_decimated
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    comment: |-
      If `channel` is set correctly, this
      should yield an identical result as
      pulse shaping followed by receive
      filtering.
    stream_id: alt_decimated
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: sent
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    comment: |-
      Matched filtering, with
      Viterbi correction of ISI
    stream_id: received
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    comment: |-
      Matched filtering, no
      attempt to correct ISI
    stream_id: no_eq
  states: {}
- name: virtual_sink_6_0
  id: virtual_sink
  parameters:
    comment: |-
      ISI-corrected receive
      filter from PSKCore
    stream_id: pskcore
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decimated
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: pskcore_decimated
  states: {}
- name: virtual_source_2_2
  id: virtual_source
  parameters:
    stream_id: decimated
  states: {}
- name: virtual_source_2_2_0
  id: virtual_source
  parameters:
    stream_id: pskcore_decimated
  states: {}
- name: virtual_source_2_2_1
  id: virtual_source
  parameters:
    stream_id: decimated
  states: {}
- name: virtual_source_3_0_1
  id: virtual_source
  parameters:
    stream_id: received
  states: {}
- name: virtual_source_3_0_1_0
  id: virtual_source
  parameters:
    stream_id: no_eq
  states: {}
- name: virtual_source_3_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: pskcore
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: sent
  states: {}
- name: virtual_source_3_1_0
  id: virtual_source
  parameters:
    stream_id: sent
  states: {}
- name: virtual_source_3_1_0_0
  id: virtual_source
  parameters:
    stream_id: sent
  states: {}

connections:
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_delay_1_1, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blks2_error_rate_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blks2_error_rate_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blks2_error_rate_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink, '0']
- [blocks_complex_to_real_0, '0', trellis_metrics_x_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_real_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_1_0_0, '0', virtual_sink_5, '0']
- [blocks_delay_1_0_0_0, '0', virtual_sink_6, '0']
- [blocks_delay_1_1, '0', virtual_sink_4, '0']
- [blocks_float_to_char_0, '0', blocks_delay_1_0_0_0, '0']
- [blocks_float_to_char_0_0, '0', virtual_sink_6_0, '0']
- [blocks_float_to_complex_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_0, '2']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_number_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_delay_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0_1, '0', virtual_sink_1, '0']
- [fir_filter_xxx_0_1_0, '0', virtual_sink_1_0, '0']
- [fir_filter_xxx_1, '0', virtual_sink_2, '0']
- [interp_fir_filter_xxx_0, '0', blocks_float_to_complex_1, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0, '0']
- [trellis_viterbi_x_0, '0', blocks_delay_1_0_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0_1, '0']
- [virtual_source_0_1, '0', fir_filter_xxx_0_1_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', qtgui_const_sink_x_0, '1']
- [virtual_source_2_2, '0', blocks_complex_to_real_0, '0']
- [virtual_source_2_2_0, '0', blocks_complex_to_real_0_0, '0']
- [virtual_source_2_2_1, '0', blocks_complex_to_real_0_1, '0']
- [virtual_source_3_0_1, '0', blks2_error_rate_0, '0']
- [virtual_source_3_0_1_0, '0', blks2_error_rate_0_0, '0']
- [virtual_source_3_0_1_0_0, '0', blks2_error_rate_0_0_0, '0']
- [virtual_source_3_1, '0', blks2_error_rate_0, '1']
- [virtual_source_3_1_0, '0', blks2_error_rate_0_0, '1']
- [virtual_source_3_1_0_0, '0', blks2_error_rate_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
