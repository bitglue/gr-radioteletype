<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtty_generation_methods</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>comment</key><value>Try changing the order (last parameter). As the
order increases, the result approaches hard keying.</value></param>
<param><key>value</key><value>extended_raised_cos(1, samp_rate, baud_rate, alpha, samp_rate/baud_rate*8 ,2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_bit</value></param>
<param><key>value</key><value>samp_rate/baud_rate</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>wave_taps</value></param>
<param><key>comment</key><value>This filter has a cutoff at the 7th harmonic of
the switching signal. Try moving the cutoff.</value></param>
<param><key>cutoff_freq</key><value>baud_rate/2*7</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>baud_rate/2</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>am_fsk_mod_bc</key>
<param><key>id</key><value>am_fsk_mod_bc_0</value></param>
<param><key>comment</key><value>Generation by controlling the envelopes of each tone.
Conceptually, two OOK modulators with a specified envelope.</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_per_bit</key><value>samp_rate/baud_rate</value></param>
<param><key>spacing</key><value>spacing</value></param>
<param><key>taps</key><value>[i/rrc_taps[len(rrc_taps)//2] for i in rrc_taps]</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*170)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*170)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*170)</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_1</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>71</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_rate/baud_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>float(baud_rate)/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>samp_rate/baud_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>float(baud_rate)/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0_0</value></param>
<param><key>length</key><value>samp_rate/baud_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>float(baud_rate)/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*100</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fm_fsk_mod_bc</key>
<param><key>id</key><value>fm_fsk_mod_bc_0</value></param>
<param><key>comment</key><value>FM generation with no waveshaping.
Produces a rectangular pulse at each frequency.</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_per_bit</key><value>samp_rate/baud_rate</value></param>
<param><key>spacing</key><value>spacing</value></param>
<param><key>taps</key><value>[1]</value></param>
</block>
<block>
<key>fm_fsk_mod_bc</key>
<param><key>id</key><value>fm_fsk_mod_bc_0_0</value></param>
<param><key>comment</key><value>Waveshaping filters the square wave fed to the FM
modulator, limiting the rise and fall times of the pulses.</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_per_bit</key><value>samp_rate/baud_rate</value></param>
<param><key>spacing</key><value>spacing</value></param>
<param><key>taps</key><value>wave_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from radioteletype.filters import extended_raised_cos</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>comment</key><value>two envelope method is
not constant-modulus</value></param>
<param><key>label1</key><value>continuous phase</value></param>
<param><key>label2</key><value>waveshaped</value></param>
<param><key>label3</key><value>switched</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>occupied bandwidth
varies significantly</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>label1</key><value>continuous phase</value></param>
<param><key>label2</key><value>waveshaped</value></param>
<param><key>label3</key><value>switched</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-15</value></param>
<param><key>ymin</key><value>-15-80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>comment</key><value>all methods compatible
with FM demodulator</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>.3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>continuous phase</value></param>
<param><key>width1</key><value>6</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>waveshaped</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>switched</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>.25</value></param>
<param><key>ymin</key><value>-1.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spacing</value></param>
<param><key>label</key><value>Spacing</value></param>
<param><key>value</key><value>170</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>continuous_phase</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>waveshaped</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>switched</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>continuous_phase</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>continuous_phase</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_1</value></param>
<param><key>stream_id</key><value>continuous_phase</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>waveshaped</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>waveshaped</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_1</value></param>
<param><key>stream_id</key><value>waveshaped</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>switched</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>switched</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_1</value></param>
<param><key>stream_id</key><value>switched</value></param>
</block>
<connection><source_block_id>am_fsk_mod_bc_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>am_fsk_mod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fm_fsk_mod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fm_fsk_mod_bc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_fsk_mod_bc_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_fsk_mod_bc_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
