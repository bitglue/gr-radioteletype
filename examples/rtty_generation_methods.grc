options:
  parameters:
    generate_options: qt_gui
    id: rtty_generation_methods
    output_language: python
  states: {}

blocks:
- name: rrc_taps
  id: variable
  parameters:
    comment: |-
      Try changing the order (last parameter). As the
      order increases, the result approaches hard keying.
    value: extended_raised_cos(1, samp_rate, baud_rate, alpha, samp_rate//baud_rate*8 ,2)
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: samp_rate/baud_rate
  states: {}
- name: wave_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      This filter has a cutoff at the 7th harmonic of
      the switching signal. Try moving the cutoff.
    cutoff_freq: baud_rate/2*7
    gain: '1.0'
    samp_rate: samp_rate
    width: baud_rate/2
    win: window.WIN_BLACKMAN
  states: {}
- name: alpha
  id: parameter
  parameters:
    label: Alpha
    value: '1'
  states: {}
- name: am_fsk_mod_bc_0
  id: am_fsk_mod_bc
  parameters:
    comment: |-
      Generation by controlling the envelopes of each tone.
      Conceptually, two OOK modulators with a specified envelope.
    samp_per_bit: samp_rate//baud_rate
    samp_rate: samp_rate
    spacing: spacing
    taps: '[i//rrc_taps[len(rrc_taps)//2] for i in rrc_taps]'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*170)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*170)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*170)
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud Rate
    type: intx
    value: '50'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '4'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '71'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate//baud_rate
    max_iter: '4000'
    scale: float(baud_rate)/samp_rate
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate//baud_rate
    max_iter: '4000'
    scale: float(baud_rate)/samp_rate
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate//baud_rate
    max_iter: '4000'
    scale: float(baud_rate)/samp_rate
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*100
    type: byte
  states: {}
- name: fm_fsk_mod_bc_0
  id: fm_fsk_mod_bc
  parameters:
    comment: |-
      FM generation with no waveshaping.
      Produces a rectangular pulse at each frequency.
    samp_per_bit: samp_rate//baud_rate
    samp_rate: samp_rate
    spacing: spacing
    taps: '[1]'
  states: {}
- name: fm_fsk_mod_bc_0_0
  id: fm_fsk_mod_bc
  parameters:
    comment: |-
      Waveshaping filters the square wave fed to the FM
      modulator, limiting the rise and fall times of the pulses.
    samp_per_bit: samp_rate//baud_rate
    samp_rate: samp_rate
    spacing: spacing
    taps: wave_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.radioteletype.filters import extended_raised_cos
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: |-
      two envelope method is
      not constant-modulus
    label1: continuous phase
    label2: waveshaped
    label3: switched
    nconnections: '3'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      occupied bandwidth
      varies significantly
    fc: '0'
    fftsize: '512'
    label1: continuous phase
    label2: waveshaped
    label3: switched
    nconnections: '3'
    showports: 'True'
    type: complex
    ymax: '-15'
    ymin: '-15-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '.3'
    comment: |-
      all methods compatible
      with FM demodulator
    grid: 'True'
    label1: continuous phase
    label2: waveshaped
    label3: switched
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    width1: '6'
    width2: '2'
    width3: '2'
    ymax: '.25'
    ymin: '-1.25'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '1000'
  states: {}
- name: spacing
  id: parameter
  parameters:
    label: Spacing
    value: '170'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: continuous_phase
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: waveshaped
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: switched
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: continuous_phase
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: continuous_phase
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: continuous_phase
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: waveshaped
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: waveshaped
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: waveshaped
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: switched
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: switched
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: switched
  states: {}

connections:
- [am_fsk_mod_bc_0, '0', virtual_sink_2, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_random_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', virtual_sink_1_0, '0']
- [blocks_delay_1, '0', virtual_sink_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_moving_average_xx_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle_0, '0', am_fsk_mod_bc_0, '0']
- [blocks_throttle_0, '0', fm_fsk_mod_bc_0, '0']
- [blocks_throttle_0, '0', fm_fsk_mod_bc_0_0, '0']
- [fm_fsk_mod_bc_0, '0', blocks_delay_1, '0']
- [fm_fsk_mod_bc_0_0, '0', blocks_delay_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_1_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_1_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '1']
- [virtual_source_2_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [virtual_source_2_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_3, '0', qtgui_const_sink_x_0, '2']
- [virtual_source_3_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [virtual_source_3_1, '0', qtgui_freq_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
