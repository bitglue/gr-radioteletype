<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>samp_rate/symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>samp_rate/32</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>10**(30.0/20)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>radioteletype.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,1)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>radioteletype.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,2)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>radioteletype.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,3)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1.0/samp_per_sym]*samp_per_sym</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2_0_0_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>radioteletype.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,4)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import radioteletype</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>The filters demonstrated here are a family of raised cosine filters. Credit
to W7AY for the idea.

http://w7ay.net/site/Technical/Extended%20Nyquist%20Filters/index.html

Filtering with a matched boxcar function provides optimal SNR in an
AWGN channel, but the passband is quite wide and likely to contain
interfering signals.

Filtering with a raised cosine filter is much narrower, and does not
generate ISI. However, it fails to capture much of the energy from the
transmission and thus degrades SNR.

The first order filter here is an ordinary raised cosine filter.

We could pretend the signal's bitrate is twice of what it is, and that each
bit is transmitted twice. To do this, we design a filter for twice the bitrate.
We make two copies of that filter, and superimpose them half the bitrate
apart.

This second order filter retains the zero-ISI property, but approaches a
more rectangular impulse response. The passband is likewise wider.

Doing this again recursively, we can get a 3rd order filter (4x the bit rate,
looking for 4 bits in a row), and so on. As the order approaches infinity
the impulse becomes a boxcar.</value></param>
<param><key>note</key><value>Explanation</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>label1</key><value>Raised Cosine</value></param>
<param><key>label2</key><value>2nd Order</value></param>
<param><key>label3</key><value>3rd Order</value></param>
<param><key>label4</key><value>4th Order</value></param>
<param><key>label5</key><value>Boxcar</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fir_filter_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fir_filter_xxx_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fir_filter_xxx_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fir_filter_xxx_0_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fir_filter_xxx_0_2_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
