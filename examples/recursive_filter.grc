options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/32
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(30.0/20)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: fir_filter_xxx_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: radioteletype.filters.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,1)
    type: ccf
  states: {}
- name: fir_filter_xxx_0_2_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: radioteletype.filters.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,2)
    type: ccf
  states: {}
- name: fir_filter_xxx_0_2_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: radioteletype.filters.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,3)
    type: ccf
  states: {}
- name: fir_filter_xxx_0_2_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0/samp_per_sym]*int(samp_per_sym)'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_2_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: radioteletype.filters.extended_raised_cos(1, samp_rate, symbol_rate, alpha, 200,4)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.radioteletype as radioteletype
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The filters demonstrated here are a family of raised cosine filters. Credit
      to W7AY for the idea.

      http://w7ay.net/site/Technical/Extended%20Nyquist%20Filters/index.html

      Filtering with a matched boxcar function provides optimal SNR in an
      AWGN channel, but the passband is quite wide and likely to contain
      interfering signals.

      Filtering with a raised cosine filter is much narrower, and does not
      generate ISI. However, it fails to capture much of the energy from the
      transmission and thus degrades SNR.

      The first order filter here is an ordinary raised cosine filter.

      We could pretend the signal's bitrate is twice of what it is, and that each
      bit is transmitted twice. To do this, we design a filter for twice the bitrate.
      We make two copies of that filter, and superimpose them half the bitrate
      apart.

      This second order filter retains the zero-ISI property, but approaches a
      more rectangular impulse response. The passband is likewise wider.

      Doing this again recursively, we can get a 3rd order filter (4x the bit rate,
      looking for 4 bits in a row), and so on. As the order approaches infinity
      the impulse becomes a boxcar.
    note: Explanation
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '128'
    label1: Raised Cosine
    label2: 2nd Order
    label3: 3rd Order
    label4: 4th Order
    label5: Boxcar
    nconnections: '5'
    showports: 'True'
    type: complex
    ymin: '-90'
  states: {}

connections:
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_2, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_2_0, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_2_0_0, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_2_0_0_0, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_2_0_0_1, '0']
- [fir_filter_xxx_0_2, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0_2_0, '0', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0_2_0_0, '0', qtgui_freq_sink_x_0, '2']
- [fir_filter_xxx_0_2_0_0_0, '0', qtgui_freq_sink_x_0, '4']
- [fir_filter_xxx_0_2_0_0_1, '0', qtgui_freq_sink_x_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
