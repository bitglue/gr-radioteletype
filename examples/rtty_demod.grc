<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtty_demod</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>45.45</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>22</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>doppler</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>doppler</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.02</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>.02</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mark</value></param>
<param><key>value</key><value>center+spacing/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>space</value></param>
<param><key>value</key><value>center-spacing/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spacing</value></param>
<param><key>value</key><value>170</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>high_cutoff_freq</key><value>samp_rate/2-200</value></param>
<param><key>low_cutoff_freq</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>10**(noise/20)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>channels_selective_fading_model</key>
<param><key>id</key><value>channels_selective_fading_model_0</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>doppler/samp_rate</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>8</value></param>
<param><key>delays</key><value>0.0,0.3,2.0</value></param>
<param><key>mags</key><value>1,0.99,0.97</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/dev/stdout</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>gr_wavfile_source_0</value></param>
<param><key>file</key><value>/home/indigo/Documents/gr-radioteletype/examples/rtty.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pulseaudio_pa_sink</key>
<param><key>id</key><value>pulseaudio_pa_sink_0</value></param>
<param><key>application_name</key><value>GNU Radio</value></param>
<param><key>channel_map</key><value></value></param>
<param><key>latency</key><value>100</value></param>
<param><key>device</key><value></value></param>
<param><key>nchannels</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>stream_name</key><value>output</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>mark</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>detector</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>mark</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>space</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>samp_rate/decimation*10</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>radioteletype_rtty_demod_cb</key>
<param><key>id</key><value>radioteletype_rtty_demod_cb_0</value></param>
<param><key>baud</key><value>baud</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>mark_freq</key><value>mark</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>space_freq</key><value>space</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>mark</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>space</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>detector</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_input</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>space</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>mark</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>detector</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_8</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_8_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>virtual_sink_input</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>pulseaudio_pa_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>channels_selective_fading_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_selective_fading_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_wavfile_source_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radioteletype_rtty_demod_cb_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radioteletype_rtty_demod_cb_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radioteletype_rtty_demod_cb_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radioteletype_rtty_demod_cb_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_8</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_8</source_block_id><sink_block_id>radioteletype_rtty_demod_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_8_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
