options:
  parameters:
    generate_options: qt_gui
    id: rtty_demod
    output_language: python
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_entry
  parameters:
    label: Freq
    type: real
    value: 20.360e6
  states: {}
- name: baud
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '50'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1000'
  states: {}
- name: decimation_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '64'
    high_cutoff_freq: '1000'
    low_cutoff_freq: '-1000'
    samp_rate: input_rate
    type: complex_band_pass
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: fm_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: input_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '200'
    audio_stop: '250'
    chan_rate: samp_rate
    deviation: '1000'
    gain: fm_gain
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: baudot_decode_bb_0
  id: baudot_decode_bb
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: gr_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: fm
    label2: bit
    nconnections: '2'
    size: round(samp_rate)
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '1'
  states: {}
- name: radioteletype_async_word_extractor_bb_0
  id: radioteletype_async_word_extractor_bb
  parameters:
    bit_rate: baud
    bits_per_word: '5'
    sample_rate: samp_rate
  states: {}
- name: rational_resampler_base_xxx_0
  id: rational_resampler_base_xxx
  parameters:
    decim: round(input_rate/samp_rate)
    interp: '1'
    taps: decimation_filter_taps
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    ant0: RX
    args: '"rtl=0,direct_samp=2,rtl_xtal=28.8e6,tuner_xtal=28.8e6"'
    bb_gain0: '30'
    bw0: input_rate/2
    dc_offset_mode0: '2'
    freq0: Freq+center_freq
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: input_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [baudot_decode_bb_0, '0', gr_file_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', radioteletype_async_word_extractor_bb_0, '0']
- [radioteletype_async_word_extractor_bb_0, '0', baudot_decode_bb_0, '0']
- [rational_resampler_base_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_base_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_base_xxx_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_base_xxx_0, '0']

metadata:
  file_format: 1
